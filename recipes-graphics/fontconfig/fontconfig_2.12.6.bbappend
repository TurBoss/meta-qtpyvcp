# FILESEXTRAPATHS_prepend := "${THISDIR}/fontconfig:"
# SRC_URI += "file://0001-Avoid-conflicts-with-integer-width-macros-from-TS-18.patch"
