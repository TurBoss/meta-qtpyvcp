COMPATIBLE_MACHINE_genericx86-64 = "genericx86-64"
